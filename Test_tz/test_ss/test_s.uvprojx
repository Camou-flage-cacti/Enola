# Keil uVision project test_s.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3_AN555 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: test_s +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-310-MPS3_AN555\corstone310_mps3_s.sct
  group Source Group 1
    ./: main.c user_func.h user_func.c instrumented_asm.h instrumented.c
software components: CMSIS Driver:I2C 1.0.1, CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:MPC 1.1.0, CMSIS Driver:PPC 1.1.0, CMSIS Driver:USART 1.1.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:Flash 1.1.0, Native Driver:I2C SBCon 1.0.0, Native Driver:MPC 1.1.0, Native Driver:PPC 1.1.0, Native Driver:SysCounter 1.0.1, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.1, Native Driver:UART 1.1.0
