# Keil uVision project test_ns.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.1.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: test_ns
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  group Source Group 1
    ./: main_ns.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Definition 1.1.0, Device:Startup 1.0.1, USB:Device:ADC 6.16.0
