# Keil uVision project IOTKit_CM33_ns.uvprojx, settings and files
target FVP (6180000::V6.18::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.1
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: IOTKit_CM33_ns
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
  group Source Group 1
    ./: main_ns.c interrupt_handlers.h interrupt_handlers.c
  group CMSE Library
    ../IOTKit_CM33_s/: Secure_Functions.h
    ../IOTKit_CM33_s/Objects/: IOTKit_CM33_s_CMSE_Lib.o
  group Documentation
    ../: README.md
target V2M-MPS2+ (6160000::V6.16::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.1
  cpu: as above
  output: IOTKit_CM33_ns
  c flags: Optim=7 OneElfS=1 v6Lang=5 wLevel=3
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
software components: CMSIS:CORE 5.5.0, Board Support:LED 2.0.0, Device:Startup 1.2.0
