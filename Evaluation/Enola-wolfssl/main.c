#include <stdio.h>
#include "Driver_USART.h"
#include "stdout.h"
#include "Device.h"
#include "enolaTrampoline.h"
#include "aes.h"
#include "simple-crypto.h"
#include "hash.h"
#include "rsa.h"

static FILE __stdio = FDEV_SETUP_STREAM(stdout_putchar, NULL, NULL, _FDEV_SETUP_WRITE);
FILE *const stdin = &__stdio;
__strong_reference(stdin, stdout);
__strong_reference(stdin, stderr);

/* Common main.c for the benchmarks

   Copyright (C) 2014 Embecosm Limited and University of Bristol
   Copyright (C) 2018-2019 Embecosm Limited

   Contributor: James Pallister <james.pallister@bristol.ac.uk>
   Contributor: Jeremy Bennett <jeremy.bennett@embecosm.com>

   This file is part of Embench and was formerly part of the Bristol/Embecosm
   Embedded Benchmark Suite.

   SPDX-License-Identifier: GPL-3.0-or-later */


   uint8_t plaintext[] = {0x1a, 0x1b, 0x1c, 0x2d, 0xe, 0xf, 0xa, 0xb};
    //uint8_t ciphertext[1024];
      //uint8_t hash_out[16];
        byte cipher[400]; // 256 bytes is large enough to store 2048 bit RSA ciphertext
      byte n[] = {0xeb, 0x6b, 0x1b, 0x08, 0x54, 0x19, 0xa6, 0x4f, 0x11, 0x02, 0x7a, 0xe0, 0x16, 0xa1, 0x54, 0x07, 0x2c, 0xf8, 0x64, 0x95, 0xa8, 0x7f, 0x1a, 0x31, 0x73, 0xcb, 0xe8, 0x33, 0xa0, 0xf7, 0x81, 0x1f, 0xaa, 0xd8, 0x31, 0x0f, 0xbb, 0xad, 0xfd, 0xd6, 0xb2, 0x3a, 0xf5, 0x70, 0xe8, 0xb3, 0x66, 0xc3, 0x72, 0x31, 0xce, 0x72, 0x6e, 0x62, 0x5f, 0x1f, 0xc3, 0xb5, 0x6d, 0x34, 0x7a, 0x61, 0x51, 0x88, 0x35, 0xf2, 0xb2, 0xfc, 0xc2, 0x9c, 0xa2, 0x91, 0xdd, 0x97, 0x13, 0xa8, 0x1f, 0x0f, 0xa5, 0xc2, 0xb2, 0x82, 0xd9, 0xbb, 0x28, 0x73, 0xf4, 0x06, 0x31, 0x94, 0xe7, 0xfd, 0x90, 0x15, 0x37, 0x74, 0xde, 0xc7, 0x42, 0x7c, 0xc4, 0x3f, 0xfe, 0x93, 0x5d, 0x12, 0x86, 0xaa, 0x46, 0x9a, 0xe2, 0x1e, 0x77, 0x2d, 0x78, 0xb6, 0x76, 0x90, 0x63, 0x97, 0xbd, 0x84, 0x4f, 0xe1, 0xaa, 0x23, 0x44, 0x45, 0x62, 0x6a, 0x7a, 0x37, 0xad, 0x20, 0x1b, 0x79, 0x94, 0xc1, 0x72, 0xfa, 0xb6, 0xe2, 0x72, 0xa1, 0xb1, 0x60, 0xc9, 0x2a, 0x2d, 0xec, 0xa3, 0x69, 0xd6, 0x18, 0x8a, 0x7a, 0xf1, 0xcf, 0xca, 0x94, 0xe4, 0x61, 0x93, 0xf2, 0x33, 0x54, 0x65, 0x99, 0x8a, 0x7f, 0xec, 0x72, 0x94, 0xc0, 0x78, 0x26, 0x6b, 0x76, 0x92, 0x02, 0x81, 0xe1, 0x89, 0x8a, 0x52, 0xf2, 0x1e, 0xf9, 0x87, 0xe2, 0x40, 0xda, 0x93, 0x2b, 0xb5, 0x12, 0x19, 0xe8, 0x10, 0x2c, 0x21, 0xc3, 0x22, 0x8d, 0xa1, 0xfd, 0x42, 0xf2, 0xaf, 0x0e, 0x43, 0x23, 0xfe, 0x56, 0xe4, 0xdc, 0x5c, 0x07, 0xd6, 0x92, 0x37, 0x6c, 0xdd, 0xc0, 0xd4, 0x83, 0xeb, 0x24, 0x06, 0xd7, 0x96, 0x73, 0xf1, 0x2f, 0x1e, 0x02, 0xe8, 0x66, 0x7f, 0xaf, 0xd5, 0x1f, 0x7b, 0x99, 0xb8, 0x2c, 0xc7, 0x30, 0xaa, 0x6d, 0xc0, 0x1e, 0x3e, 0x7a, 0x8d, 0x13};
  byte e[] = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01};
int __attribute__ ((used))
main (int argc __attribute__ ((unused)),
      char *argv[] __attribute__ ((unused)))
{

    /*AES 128-bit test*/
//    Aes ctx;

//    size_t len = 1024;
//     init_trampoline();
//    int result; // Library result
//     if (len <= 0 || len % BLOCK_SIZE)
//         return -1;
//    result = wc_AesSetKey(&ctx, key, 16, NULL, AES_ENCRYPTION);
//     if (result != 0)
//         return result; // Report error
//        // Encrypt each block
//     for (int i = 0; i < len - 1; i += BLOCK_SIZE) {
//         result = wc_AesEncryptDirect(&ctx, ciphertext + i, plaintext + i);
//         if (result != 0)
//             return result; // Report error
//     }
//     memset(plaintext, 0, 32*32);
//         // Decrypt each block
//     result = wc_AesSetKey(&ctx, key, 16, NULL, AES_DECRYPTION);
//     for (int i = 0; i < len - 1; i += BLOCK_SIZE) {
//         result = wc_AesDecryptDirect(&ctx, plaintext + i, ciphertext + i);
//         if (result != 0)
//             return result; // Report error
//     }
  /*MD5sum*/
  //  init_trampoline();
  // size_t len = 1024;

  // wc_Md5Hash(plaintext, len, hash_out);
  /*RSA */
  RsaKey pub;
  int ret;
  WC_RNG rng;
  ret = wc_InitRsaKey(&pub, NULL);  // not using heap hint. No custom memory
  if ( ret != 0 ) {

  }
  ret = wc_InitRng(&rng);
  if( ret != 0 ) {
    // error parsing public key elements
  }



  // not using heap hint. No custom memory
  word32 idx = 0;
  ret = wc_RsaPublicKeyDecodeRaw(n, sizeof(n), e, sizeof(e), &pub);
  if( ret != 0 ) {
    // error parsing public key elements
  }

  // ret = wc_RsaPrivateKeyDecode(priv_key, &idx, &pub, sizeof(priv_key));
  // if( ret != 0 ) {
  //     // error parsing private key
  // }
  // idx = 0;
  // ret = wc_RsaPublicKeyDecode(pub_key, &idx, &pub, sizeof(pub_key));
  // if( ret != 0 ) {
  //     // error parsing public key
  // }
  // initialize with received public key parameters
  ret = wc_RsaPublicEncrypt(plaintext, sizeof(plaintext), cipher, sizeof(cipher), &pub, &rng);
  if ( ret != 0 ) {
    init_trampoline();
  }

}                               /* main () */


/*
   Local Variables:
   mode: C
   c-file-style: "gnu"
   End:
*/