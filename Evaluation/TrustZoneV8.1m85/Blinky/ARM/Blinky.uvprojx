# Keil uVision project Blinky.uvprojx, settings and files
target ARMCLANG (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3_FVP ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.4.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-padded -Wno-covered-switch-default
  c include: ..\API\Include
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-310-MPS3_FVP\linker_SSE310MPS3_secure.sct
  group Example
    ../: Blinky.c main.c Blinky.h
    ../API/Source/: led_port.c
    ../API/Include/: led_port.h
  group Documentation
    ../: Abstract.txt
target GCC (6190000::V6.19::ARMCLANG)
  device: SSE-310-MPS3_FVP ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.4.0
  cpu: as above
  output: Blinky
  BeforeMake: arm-none-eabi-gcc -E -P -x c -I./ "$PRTE\Device\$D\linker_SSE310MPS3_secure.ld" -o "$Llinker_SSE310MPS3_secure_proc.ld"
software components: CMSIS Driver:USART 1.1.0, CMSIS:CORE 6.0.0, Device:Definition 2.0.0, Device:Native Driver:IO 1.0.1, Device:Native Driver:SysCounter 1.0.1, Device:Native Driver:SysTimer 1.0.0, Device:Native Driver:Timeout 1.0.1, Device:Native Driver:UART 1.1.0, Device:Startup 2.0.0, Device:UART STDOUT 1.0.0, Compiler:I/O:STDOUT 1.2.0
