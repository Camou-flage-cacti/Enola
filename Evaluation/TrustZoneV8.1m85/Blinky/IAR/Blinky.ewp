# IAR project Blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\API\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: Blinky.srec
  ILINK.IlinkOutputFile: Blinky.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Abstract.txt Blinky.c Blinky.h main.c
  group API/Include
    ../API/Include/: led_port.h
  group API/Source
    ../API/Source/: led_port.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Device UART STDOUT
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.2.0}$/Device/Source/: stdout_USART.c
  group CMSIS-Pack/Device.Native Driver IO
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Device/Source/: arm_mps3_io_drv.c
  group CMSIS-Pack/Device.Native Driver SysCounter
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Device/Source/: syscounter_armv8-m_cntrl_drv.c syscounter_armv8-m_read_drv.c
  group CMSIS-Pack/Device.Native Driver SysTimer
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Device/Source/: systimer_armv8-m_drv.c
  group CMSIS-Pack/Device.Native Driver Timeout
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Device/Source/: systimer_armv8-m_timeout.c
  group CMSIS-Pack/Device.Native Driver UART
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Device/Source/: uart_cmsdk_drv.c
  group CMSIS-Pack/Device.Startup C Startup
    ../RTE/Device/SSE-310-MPS3_FVP/: linker_SSE310MPS3_secure.icf region_defs.h region_limits.h startup_SSE310MPS3.c system_SSE310MPS3.c
  group CMSIS-Pack/CMSIS Driver USART
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/CMSIS_Driver/: Driver_USART.c
  group CMSIS-Pack/Device Definition
    ../RTE/Device/SSE-310-MPS3_FVP/: cmsis_driver_config.h device_cfg.h
    ${CMSIS_PACK_PATH_ARM#V2M_MPS3_SSE_310_BSP#1.3.0}$/Board/Device_Definition/: device_definition.c
