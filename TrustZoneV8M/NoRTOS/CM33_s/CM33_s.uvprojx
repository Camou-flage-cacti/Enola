# Keil uVision project CM33_s.uvprojx, settings and files
target FVP Simulation Model (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3_AN555 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: CM33_s
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\ARMCM33_DSP_FP_TZ\ARMCM33_ac6_s.sct
  link misc: --import-cmse-lib-out="..\CM33_s\Objects\CM33_s_CMSE_Lib.o"
  group Secure Code
    ./: main_s.c
  group Interface
    ./: interface.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS Driver:MPC 1.1.0, CMSIS:CORE 5.6.0, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:MPC 1.1.0, Native Driver:SysCounter 1.0.1, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.1
